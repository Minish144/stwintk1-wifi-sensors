# IAR project Project.ewp, settings and files
configuration STWIN_BLE_SampleApp (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9ZI ST STM32L4R9ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\Components\hts221; ..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\Drivers\BSP\STWIN; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\Drivers\BSP\Components\stts751; ..\..\..\Middlewares\ST\BlueNRG-2\hci\hci_tl_patterns\Basic; ..\..\..\Middlewares\ST\BlueNRG-2\includes; ..\..\..\Middlewares\ST\BlueNRG-2\utils
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_SampleApp.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l4r9xI_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BLE_SampleApp/EWARM
    ./: startup_stm32l4r9xx.s
  group BLE_SampleApp/User
    ../Src/: gatt_db.c hci_tl_interface.c main.c sensor_service.c stm32l4xx_hal_exti.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/STWIN
    ../../../Drivers/BSP/STWIN/: STWIN.c STWIN_bc.c STWIN_bus.c STWIN_env_sensors.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/X-CUBE-BLE2/Wireless/Controller
    ../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/X-CUBE-BLE2/Wireless/HCI_TL/Basic
    ../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/X-CUBE-BLE2/Wireless/Utils
    ../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
