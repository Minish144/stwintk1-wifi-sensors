# IAR project Project.ewp, settings and files
configuration STWIN_DATALOG (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9ZI ST STM32L4R9ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\Components\hts221; ..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\STWIN; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\Drivers\BSP\Components\iis2dh; ..\..\..\Drivers\BSP\Components\iis3dwb; ..\..\..\Drivers\BSP\Components\stts751
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: DataLog.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l4r9xI_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l4r9xx.s
  group Application/User
    ../Src/: datalog_application.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../Drivers/BSP/Components/iis2dh/: iis2dh.c iis2dh_reg.c
    ../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/STWIN
    ../../../Drivers/BSP/STWIN/: STWIN.c STWIN_bc.c STWIN_bus.c STWIN_env_sensors.c STWIN_motion_sensors.c STWIN_motion_sensors_ex.c STWIN_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c
  group Middlewares/Class/CDC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/Core
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
